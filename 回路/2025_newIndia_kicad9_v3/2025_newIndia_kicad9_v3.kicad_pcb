# Repository robohachi/robohachi_denki_2025

## KiCad design 回路/2025_MD_mother_f303/2025_MD_mother_f303.kicad_pcb

Parts:
C1, C2: 0.1u; C_Disc_D3.0mm_W1.6mm_P2.50mm
D1: LED; LED_D3.0mm
J1: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J2: XT60PW-M; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal; PARTREV V1.2
J3, J4, J5, J6, J7: XT60-F; AMASS_XT60-F_1x02_P7.20mm_Vertical; PARTREV V1.2
R41: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
U1: nucleo-32; NUCLEO-32
U27: MCP2561-E-P; DIP-8_W7.62mm
U28: 74HC595; DIP-16_W7.62mm_LongPads

Connections:
+5VD: C1.1, C2.1, U1.27 (+5V), U27.3 (VDD), U28.10 (~SRCLR), U28.16 (VCC)
/CAN_RX: U1.13 (D10), U27.4 (RXD)
/CAN_TX: U1.5 (D2), U27.1 (TXD)
/DIR_1: U1.22 (A3); also elsewhere on the board
/DIR_2: U1.23 (A4); also elsewhere on the board
/DIR_3: U28.15 (QA); also elsewhere on the board
/DIR_4: U28.1 (QB); also elsewhere on the board
/DIR_5: U28.2 (QC); also elsewhere on the board
/DIR_6: U28.3 (QD); also elsewhere on the board
/DIR_7: U28.4 (QE); also elsewhere on the board
/DIR_8: U28.5 (QF); also elsewhere on the board
/DIR_9: U28.6 (QG); also elsewhere on the board
/DIR_10: U28.7 (QH); also elsewhere on the board
/LEDPin: D1.2 (A), U1.11 (D8)
/PWM_1: U1.12 (D9); also elsewhere on the board
/PWM_2: U1.1 (D1); also elsewhere on the board
/PWM_3: U1.2 (D0); also elsewhere on the board
/PWM_4: U1.19 (A0); also elsewhere on the board
/PWM_5: U1.20 (A1); also elsewhere on the board
/PWM_6: U1.21 (A2); also elsewhere on the board
/PWM_7: U1.24 (A5); also elsewhere on the board
/PWM_8: U1.25 (A6); also elsewhere on the board
/PWM_9: U1.6 (D3); also elsewhere on the board
/PWM_10: U1.9 (D6); also elsewhere on the board
/clockPin: U1.14 (D11), U28.11 (SRCLK)
/dataPin: U1.16 (D13), U28.14 (SER)
/latchPin: U1.15 (D12), U28.12 (RCLK)
GNDD: C1.2, C2.2, J1.3, R41.2, U1.4 (GND), U1.29 (GND), U27.2 (VSS), U27.8 (STBY), U28.8 (GND), U28.13 (~OE); also elsewhere on the board
unnamed: D1.1 (K), R41.1
unnamed: J1.1, U27.6 (CANL)
unnamed: J1.2, U27.7 (CANH)
unnamed: J2.1 (+), J3.1 (+), J4.1 (+), J5.1 (+), J6.1 (+), J7.1 (+)
unnamed: J2.2 (-), J3.2 (-), J4.2 (-), J5.2 (-), J6.2 (-), J7.2 (-)

Notes on the sheet:
マザボ
電源引き回し

Parts:
R1, R3, R5, R7: 100; R_0805_2012Metric; LCSC C17408
R2, R4, R6, R8: 100k; R_0805_2012Metric; LCSC C149504
U2, U4, U5, U6: TLP185; SO-6_4.4x3.6mm_P1.27mm
U3: M.D; MD

Connections:
/DIR_1: U2.1; also elsewhere on the board
/DIR_2: U5.1; also elsewhere on the board
/PWM_1: U4.1; also elsewhere on the board
/PWM_2: U6.1; also elsewhere on the board
GNDD: R1.1, R3.1, R5.1, R7.1; also elsewhere on the board
unnamed: R1.2, U2.3
unnamed: R3.2, U4.3
unnamed: R5.2, U5.3
unnamed: R7.2, U6.3
unnamed: R2.1, U2.4, U3.2 (DIR1)
unnamed: R6.1, U3.7 (DIR2), U5.4
unnamed: R2.2, R4.2, U3.1 (GND1)
unnamed: R6.2, R8.2, U3.6 (GND2)
unnamed: R4.1, U3.3 (PWM1), U4.4
unnamed: R8.1, U3.8 (PWM2), U6.4
unnamed: U2.6, U3.5 (VDD1), U4.6
unnamed: U3.10 (VDD2), U5.6, U6.6

Parts of its further copies:
R9, R10, R11, R12, R17, R18, R19, R20, R25, R26, R27, R28, R33, R34, R35, R36: 100; R_0805_2012Metric; LCSC C17408
R13, R14, R15, R16, R21, R22, R23, R24, R29, R30, R31, R32, R37, R38, R39, R40: 100k; R_0805_2012Metric; LCSC C149504
U7, U8, U9, U10, U12, U13, U14, U15, U17, U18, U19, U20, U22, U23, U24, U25: TLP185; SO-6_4.4x3.6mm_P1.27mm
U11, U16, U21, U26: M.D; MD

Connections of its further copies:
/DIR_3: U7.1; also elsewhere on the board
/DIR_4: U9.1; also elsewhere on the board
/DIR_5: U12.1; also elsewhere on the board
/DIR_6: U14.1; also elsewhere on the board
/DIR_7: U17.1; also elsewhere on the board
/DIR_8: U19.1; also elsewhere on the board
/DIR_9: U22.1; also elsewhere on the board
/DIR_10: U24.1; also elsewhere on the board
/PWM_3: U8.1; also elsewhere on the board
/PWM_4: U10.1; also elsewhere on the board
/PWM_5: U13.1; also elsewhere on the board
/PWM_6: U15.1; also elsewhere on the board
/PWM_7: U18.1; also elsewhere on the board
/PWM_8: U20.1; also elsewhere on the board
/PWM_9: U23.1; also elsewhere on the board
/PWM_10: U25.1; also elsewhere on the board
GNDD: R9.1, R10.1, R11.1, R12.1, R17.1, R18.1, R19.1, R20.1, R25.1, R26.1, R27.1, R28.1, R33.1, R34.1, R35.1, R36.1; also elsewhere on the board
unnamed: R9.2, U7.3
unnamed: R10.2, U8.3
unnamed: R11.2, U9.3
unnamed: R12.2, U10.3
unnamed: R17.2, U12.3
unnamed: R18.2, U13.3
unnamed: R19.2, U14.3
unnamed: R20.2, U15.3
unnamed: R25.2, U17.3
unnamed: R26.2, U18.3
unnamed: R27.2, U19.3
unnamed: R28.2, U20.3
unnamed: R33.2, U22.3
unnamed: R34.2, U23.3
unnamed: R35.2, U24.3
unnamed: R36.2, U25.3
unnamed: R13.1, U7.4, U11.2 (DIR1)
unnamed: R15.1, U9.4, U11.7 (DIR2)
unnamed: R13.2, R14.2, U11.1 (GND1)
unnamed: R15.2, R16.2, U11.6 (GND2)
unnamed: R14.1, U8.4, U11.3 (PWM1)
unnamed: R16.1, U10.4, U11.8 (PWM2)
unnamed: U7.6, U8.6, U11.5 (VDD1)
unnamed: U9.6, U10.6, U11.10 (VDD2)
unnamed: R21.1, U12.4, U16.2 (DIR1)
unnamed: R23.1, U14.4, U16.7 (DIR2)
unnamed: R21.2, R22.2, U16.1 (GND1)
unnamed: R23.2, R24.2, U16.6 (GND2)
unnamed: R22.1, U13.4, U16.3 (PWM1)
unnamed: R24.1, U15.4, U16.8 (PWM2)
unnamed: U12.6, U13.6, U16.5 (VDD1)
unnamed: U14.6, U15.6, U16.10 (VDD2)
unnamed: R29.1, U17.4, U21.2 (DIR1)
unnamed: R31.1, U19.4, U21.7 (DIR2)
unnamed: R29.2, R30.2, U21.1 (GND1)
unnamed: R31.2, R32.2, U21.6 (GND2)
unnamed: R30.1, U18.4, U21.3 (PWM1)
unnamed: R32.1, U20.4, U21.8 (PWM2)
unnamed: U17.6, U18.6, U21.5 (VDD1)
unnamed: U19.6, U20.6, U21.10 (VDD2)
unnamed: R37.1, U22.4, U26.2 (DIR1)
unnamed: R39.1, U24.4, U26.7 (DIR2)
unnamed: R37.2, R38.2, U26.1 (GND1)
unnamed: R39.2, R40.2, U26.6 (GND2)
unnamed: R38.1, U23.4, U26.3 (PWM1)
unnamed: R40.1, U25.4, U26.8 (PWM2)
unnamed: U22.6, U23.6, U26.5 (VDD1)
unnamed: U24.6, U25.6, U26.10 (VDD2)

Board: 2 copper layers, 98.0 x 89.0 mm, 79 parts (20 on the bottom side), 93 nets.

## Commit log

2026-01-26 Create 制御
    制御プログラムを書くファイル
2026-01-26 create 制御 folder
    制御プログラムの共有を行うフォルダ
2026-01-26 Create README.md
    制御プログラムを共有するディレクトリ
2026-01-26 add 回路フォルダ MDプロジェクト MDマザボプロジェクト
2026-04-03 STM32CubeIDEのプロジェクトを追加
